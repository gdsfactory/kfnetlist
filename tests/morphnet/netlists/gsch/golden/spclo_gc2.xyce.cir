.title schematic
